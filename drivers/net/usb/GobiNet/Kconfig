## drivers/net/usb/GobiNet/Kconfig
```kconfig
config NET_GOBINET
	tristate "GOBINET Driver support"
	depends on USB_USBNET
	default n
```
